# Keil uVision project blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32F30x\Include;.\CMSIS\Device\ST\STM32F30x\Source;.\STM32F30x_StdPeriph_Driver;.\STM32F30x_StdPeriph_Driver\inc;.\STM32F30x_StdPeriph_Driver\src;.\application\inc;.\application\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group application
    ./application/src/: main.c
  group SPL
    ./STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
    ./STM32F30x_StdPeriph_Driver/: stm32f30x_conf.h
  group CMSIS
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group StartUp
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f303xc.s
